# Keil uVision project LCDTest.uvprojx, settings and files
target LCDTest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C1233H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCDTest
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --fpu=fpv4-sp --c99
  c include: ..;..\..\..
  asm include: ../
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s LCDTestMain.c
    ../inc/: SSD2119.c PLL.c
software components: CMSIS:CORE 5.0.2
