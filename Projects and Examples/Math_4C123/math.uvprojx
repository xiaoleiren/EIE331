# Keil uVision project math.uvprojx, settings and files
target math (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: math
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: Startup.s main.c circle.s sqrt.s
    ../inc/: SysTick.c
software components: CMSIS:CORE 5.0.2
