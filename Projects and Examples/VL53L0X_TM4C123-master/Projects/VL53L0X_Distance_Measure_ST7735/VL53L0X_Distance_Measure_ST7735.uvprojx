# Keil uVision project VL53L0X_Distance_Measure_ST7735.uvprojx, settings and files
target VL53L0X_Distance_Measure_ST7735 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VL53L0X_Distance_Measure_ST7735
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ../../inc;../../VL53L0X;../../VL53L0X_I2C/;../../core/inc;../../platform/inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Files
    ../../inc/: LED.c PLL.c startup.s ST7735.c
    ../../VL53L0X_I2C/: VL53L0X_I2C.c
    ../../VL53L0X/: VL53L0X.c
    ../../core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../../platform/src/: vl53l0x_platform.c
    ./: VL53L0X_Distance_Measure_ST7735.c
software components: CMSIS:CORE 5.0.2
